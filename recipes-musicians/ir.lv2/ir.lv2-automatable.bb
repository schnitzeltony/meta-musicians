require ir.lv2.inc

SUMMARY = "IR LV2 convolution reverb (automatable)"

IR_LV2_BRANCH = "automatable"
SRCREV = "a523bba0f336d26197b271b64799c4f369e487a8"
PV = "1.3.4+git${SRCPV}"

IR_LV2_VARIANT = "auto"
IR_LV2_DOAP_EXTENSION = "automatable"
