require ir.lv2.inc

SUMMARY = "IR LV2 convolution reverb (zero-latency)"

IR_LV2_BRANCH = "zero-latency"
SRCREV = "38bf3ec7d370d8234dd55be99c14cf9533b43c60"
PV = "1.2.4+git${SRCPV}"

IR_LV2_VARIANT = "zero"
IR_LV2_DOAP_EXTENSION = "zero-latency"
