PACKAGECONFIG_append = " gui imageformats"

